# Autodesk Inventor part: 서브 축
## iProperties
Created: 2012-07
Part Number: 서브 축
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
