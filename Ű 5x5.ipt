# Autodesk Inventor part: 키 5x5
## iProperties
Created: 2012-07
Part Number: 키 5x5
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
