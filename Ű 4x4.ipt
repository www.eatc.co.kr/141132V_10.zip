# Autodesk Inventor part: 키 4x4
## iProperties
Created: 2012-07
Part Number: 키 4x4
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
