# Autodesk Inventor part: 메인 축
## iProperties
Created: 2012-07
Part Number: 메인 축
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
